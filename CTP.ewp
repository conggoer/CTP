# IAR project CTP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD
  ICCARM.CCIncludePath2: App; Bsp; Libraries\CMSIS\DeviceSupport; Libraries\CMSIS\DeviceSupport\startup; Libraries\STM32F10x_StdPeriph_Driver\inc; FreeRTOS\include; FreeRTOS\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: App
  OBJCOPY.OOCOutputFile: CTP.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    App/: adc.c app_task.c can.c CSB.c FreeRTOSConfig.h main.c PID.c stm32f10x_it.c timer.c usart.c
  group Bsp
    Bsp/: bsp.c
  group CMSIS
    Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group Doc
    Doc/: ReadMe.txt
  group FreeRTOS/Ports
    FreeRTOS/portable/MemMang/: heap_4.c
    FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group FreeRTOS/Source
    FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Startup Code
    Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
